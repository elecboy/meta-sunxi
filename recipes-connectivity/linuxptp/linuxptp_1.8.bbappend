FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0002-fix-build-with-kernel-headers-4.19.patch\
	    "
